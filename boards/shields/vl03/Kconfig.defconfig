## boards/shields/vl03/Kconfig.defconfig
```kconfig
if SHIELD_VL03

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "VL03"

endif
```
